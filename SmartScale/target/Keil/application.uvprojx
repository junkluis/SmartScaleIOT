# Keil uVision project application.uvprojx, settings and files
target STM32F746G-DISCO (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: application +hex
  AfterMake: fromelf --only=ExtFlashSection --bin --output=binary .\Flash\application.axf
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: ST STM32F756xx USE_FREERTOS_8 USE_OS_SYSTICK USE_STM32746G_DISCOVERY USE_BPP=16
  c include: ../../touchgfx/framework/include;../../gui/include;../../platform/os;../../generated/fonts/include;../../generated/images/include;../../generated/texts/include;../../generated/gui_generated/include;../bsp/include;../bsp/include/platform/core/arm/cortex-m/CMSIS;../bsp/include/platform/stm32f7xx;../bsp/include/platform/stm32f7xx/CMSIS;../bsp/include/platform/stm32f7xx/STM32F7xx_HAL_Driver;../bsp/include;../bsp/include/vendor;../bsp/source/vendor/STM32746G-Discovery;../os/FreeRTOS8.2.0/Source/include;../os/FreeRTOS8.2.0/Source/portable/RVDS/ST_CM7
  asm include: ../os/FreeRTOSV8.2.0/FreeRTOS/Source/include;../os/FreeRTOSV8.2.0/FreeRTOS/Source/portable/RVDS/ST_CM7
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  scatter file: .\Flash_QSPI.sct
  group Startup
    ../: main.cpp
    ../bsp/source/platform/stm32f7xx/CMSIS/: system_stm32f7xx.c
    ../bsp/source/platform/stm32f7xx/Keil/: startup_stm32f746xx.s
  group TouchGFXHAL
    ../bsp/source/platform/stm32f7xx/: STM32F7DMA.cpp STM32F7HAL.cpp
    ../bsp/source/: BoardConfiguration.cpp GPIO.cpp
    ../bsp/source/bsp/: STM32F7Instrumentation.cpp STM32F746GTouchController.cpp
    ../bsp/source/vendor/STM32746G-Discovery/: stm32746g_discovery.c stm32746g_discovery_lcd.c stm32746g_discovery_sd.c stm32746g_discovery_sdram.c stm32746g_discovery_ts.c stm32746g_discovery_qspi.c
  group OS
    ../os/FreeRTOS8.2.0/Source/: croutine.c event_groups.c list.c queue.c readme.txt tasks.c timers.c
    ../os/FreeRTOS8.2.0/: OSWrappers.cpp
    ../os/FreeRTOS8.2.0/Source/portable/RVDS/ST_CM7/: port.c
    ../os/FreeRTOS8.2.0/Source/portable/MemMang/: heap_2.c
  group HAL
    ../bsp/source/vendor/Components/ft5336/: ft5336.c
    ../bsp/source/platform/stm32f7xx/STM32F7xx_HAL_Driver/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_can.c stm32f7xx_hal_cec.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_cryp.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_dac.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_eth.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_hash.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_hcd.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_i2s.c stm32f7xx_hal_irda.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_lptim.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_msp_template.c stm32f7xx_hal_nand.c stm32f7xx_hal_nor.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_smartcard.c stm32f7xx_hal_smartcard_ex.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_spi.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_hal_wwdg.c stm32f7xx_ll_fmc.c stm32f7xx_ll_sdmmc.c stm32f7xx_ll_usb.c
  group Lib
    ../../touchgfx/lib/core/cortex_m7/Keil/: touchgfx_core.lib
  group gui
    ../../gui/src/balanzainteligente_screen/: balanzainteligentepresenter.cpp balanzainteligenteview.cpp
    ../../gui/src/common/: customkeyboard.cpp frontendapplication.cpp
    ../../gui/src/informacion_screen/: informacionpresenter.cpp informacionview.cpp
    ../../gui/src/menuprincipal_screen/: menuprincipalpresenter.cpp menuprincipalview.cpp
    ../../gui/src/model/: model.cpp
    ../../gui/src/numpad_screen/: numpadpresenter.cpp numpadview.cpp
    ../../gui/src/perfilproductos_screen/: perfilproductospresenter.cpp perfilproductosview.cpp
    ../../gui/src/screensaver_screen/: screensaverpresenter.cpp screensaverview.cpp
    ../../gui/src/teclado_screen/: tecladopresenter.cpp tecladoview.cpp
  group generated
    ../../generated/fonts/src/: applicationfontprovider.cpp cachedfont.cpp font_fradm_ttf_18_4bpp_0.cpp font_fradm_ttf_18_4bpp_4.cpp font_verdana_10_4bpp_0.cpp font_verdana_10_4bpp_4.cpp font_verdana_15_4bpp_0.cpp font_verdana_15_4bpp_4.cpp font_verdana_18_4bpp_0.cpp font_verdana_20_4bpp_0.cpp font_verdana_20_4bpp_4.cpp font_verdana_24_4bpp_0.cpp font_verdana_24_4bpp_4.cpp font_verdana_28_4bpp_0.cpp font_verdana_28_4bpp_4.cpp font_verdana_40_4bpp_0.cpp font_verdana_40_4bpp_4.cpp font_verdanab_25_4bpp_0.cpp font_verdanab_25_4bpp_4.cpp fontcache.cpp generatedfont.cpp kerning_fradm_ttf_18_4bpp.cpp kerning_verdana_10_4bpp.cpp kerning_verdana_15_4bpp.cpp kerning_verdana_18_4bpp.cpp kerning_verdana_20_4bpp.cpp kerning_verdana_24_4bpp.cpp kerning_verdana_28_4bpp.cpp kerning_verdana_40_4bpp.cpp kerning_verdanab_25_4bpp.cpp table_fradm_ttf_18_4bpp.cpp table_verdana_10_4bpp.cpp table_verdana_15_4bpp.cpp table_verdana_18_4bpp.cpp table_verdana_20_4bpp.cpp table_verdana_24_4bpp.cpp table_verdana_28_4bpp.cpp table_verdana_40_4bpp.cpp table_verdanab_25_4bpp.cpp
    ../../generated/images/src/: ayuda1.cpp ayuda2.cpp ayuda3.cpp ayuda4.cpp background-title.cpp background.cpp bitmapdatabase.cpp botonperfil.cpp botonperfilpressed.cpp bottom_slide_menu_background.cpp bottom_slide_menu_button.cpp btn-central-push.cpp btn-central.cpp btn-ok-pressed.cpp btn-ok.cpp btn-pressed.cpp btn.cpp cont1.cpp cont2.cpp cont3.cpp cont4.cpp container.cpp edit.cpp erase.cpp home.cpp icon_keyboard_even_row.cpp icon_keyboard_highlighted.cpp icon_keyboard_odd_row.cpp keyboard_background.cpp keyboard_key_delete_highlighted.cpp keyboard_key_highlighted.cpp keyboard_key_num_highlighted.cpp keyboard_key_shift_highlighted.cpp keyboard_space_highlighted.cpp left_slide_menu_background.cpp left_slide_menu_button.cpp menu_button_00.cpp menu_button_01.cpp menu_button_02.cpp menu_button_03.cpp menu_button_04.cpp menu_button_pressed_00.cpp menu_button_pressed_01.cpp menu_button_pressed_02.cpp menu_button_pressed_03.cpp menu_button_pressed_04.cpp menu_icon.cpp menu_toggle_button_00.cpp menu_toggle_button_01.cpp menu_toggle_button_02.cpp menu_toggle_button_03.cpp menu_toggle_button_selected_00.cpp menu_toggle_button_selected_01.cpp menu_toggle_button_selected_02.cpp menu_toggle_button_selected_03.cpp menua.cpp menub.cpp menuc.cpp menud.cpp menue.cpp menuf.cpp modal_background.cpp right_slide_menu_background.cpp right_slide_menu_button.cpp round_icon_button.cpp round_icon_button_pressed.cpp s.cpp screensaver.cpp send.cpp sigfox.cpp sigfoxpressed.cpp text-field.cpp top_slide_menu_background.cpp top_slide_menu_button.cpp warning.cpp
    ../../generated/gui_generated/src/balanzainteligente_screen/: balanzainteligenteviewbase.cpp
    ../../generated/images/src/__designer/: blue_backgrounds_main_bg_480x272px.cpp blue_buttons_round_edge_icon_button.cpp blue_buttons_round_edge_icon_button_pressed.cpp blue_buttons_round_edge_small.cpp blue_buttons_round_edge_small_pressed.cpp blue_buttons_round_icon_button.cpp blue_buttons_round_icon_button_pressed.cpp blue_buttons_round_small.cpp blue_buttons_round_small_pressed.cpp blue_buttons_square_icon_button.cpp blue_buttons_square_icon_button_pressed.cpp blue_icons_down_arrow_32.cpp blue_icons_up_arrow_32.cpp blue_pageindicator_dot_indicator_small_highlight.cpp blue_pageindicator_dot_indicator_small_normal.cpp
    ../../generated/gui_generated/src/common/: frontendapplicationbase.cpp
    ../../generated/gui_generated/src/informacion_screen/: informacionviewbase.cpp
    ../../generated/texts/src/: languagegb.cpp texts.cpp typedtextdatabase.cpp
    ../../generated/gui_generated/src/menuprincipal_screen/: menuprincipalviewbase.cpp
    ../../generated/gui_generated/src/numpad_screen/: numpadviewbase.cpp
    ../../generated/gui_generated/src/perfilproductos_screen/: perfilproductosviewbase.cpp
    ../../generated/gui_generated/src/screensaver_screen/: screensaverviewbase.cpp
    ../../generated/gui_generated/src/teclado_screen/: tecladoviewbase.cpp
