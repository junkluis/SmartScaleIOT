# IAR project application.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429NI ST STM32F429NI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: ST; STM32F756xx; USE_FREERTOS_8; USE_OS_SYSTICK; USE_STM32746G_DISCOVERY; USE_BPP=16
  ICCARM.CCIncludePath2: ..\..\gui\include; ..\..\target\include; ..\..\platform\os; ..\..\generated\fonts\include; ..\..\generated\images\include; ..\..\generated\texts\include; ..\..\generated\gui_generated\include; ..\..\touchgfx\framework\include; ..\bsp\include\platform\core\arm\cortex-m\CMSIS; ..\bsp\include\platform\stm32f7xx; ..\bsp\include\platform\stm32f7xx\CMSIS; ..\bsp\include\platform\stm32f7xx\STM32F7xx_HAL_Driver; ..\bsp\include; ..\bsp\include\vendor; ..\bsp\source\vendor\STM32746G-Discovery; ..\os\FreeRTOS8.2.0\Source\include; ..\os\FreeRTOS8.2.0\Source\portable\IAR\ST_CM7
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: USE_FREERTOS_8; USE_OS_SYSTICK
  AARM.AUserIncludes: ..\..\platform\os
  OBJCOPY.OOCOutputFile: application.hex
  ILINK.IlinkOutputFile: application.out
  ILINK.IlinkIcfFile: application.icf
  ILINK.IlinkAdditionalLibs: ..\..\touchgfx\lib\core\cortex_m7\IAR8.x\touchgfx_core.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/generated/fonts
    ../../generated/fonts/src/: ApplicationFontProvider.cpp CachedFont.cpp Font_FRADM_TTF_18_4bpp_0.cpp Font_FRADM_TTF_18_4bpp_4.cpp Font_verdana_10_4bpp_0.cpp Font_verdana_10_4bpp_4.cpp Font_verdana_15_4bpp_0.cpp Font_verdana_15_4bpp_4.cpp Font_verdana_18_4bpp_0.cpp Font_verdana_20_4bpp_0.cpp Font_verdana_20_4bpp_4.cpp Font_verdana_24_4bpp_0.cpp Font_verdana_24_4bpp_4.cpp Font_verdana_28_4bpp_0.cpp Font_verdana_28_4bpp_4.cpp Font_verdana_40_4bpp_0.cpp Font_verdana_40_4bpp_4.cpp Font_verdanab_25_4bpp_0.cpp Font_verdanab_25_4bpp_4.cpp FontCache.cpp GeneratedFont.cpp Kerning_FRADM_TTF_18_4bpp.cpp Kerning_verdana_10_4bpp.cpp Kerning_verdana_15_4bpp.cpp Kerning_verdana_18_4bpp.cpp Kerning_verdana_20_4bpp.cpp Kerning_verdana_24_4bpp.cpp Kerning_verdana_28_4bpp.cpp Kerning_verdana_40_4bpp.cpp Kerning_verdanab_25_4bpp.cpp Table_FRADM_TTF_18_4bpp.cpp Table_verdana_10_4bpp.cpp Table_verdana_15_4bpp.cpp Table_verdana_18_4bpp.cpp Table_verdana_20_4bpp.cpp Table_verdana_24_4bpp.cpp Table_verdana_28_4bpp.cpp Table_verdana_40_4bpp.cpp Table_verdanab_25_4bpp.cpp
  group Application/generated/gui_generated/balanzainteligente_screen
    ../../generated/gui_generated/src/balanzainteligente_screen/: BalanzaInteligenteViewBase.cpp
  group Application/generated/gui_generated/common
    ../../generated/gui_generated/src/common/: FrontendApplicationBase.cpp
  group Application/generated/gui_generated/informacion_screen
    ../../generated/gui_generated/src/informacion_screen/: InformacionViewBase.cpp
  group Application/generated/gui_generated/menuprincipal_screen
    ../../generated/gui_generated/src/menuprincipal_screen/: MenuPrincipalViewBase.cpp
  group Application/generated/gui_generated/numpad_screen
    ../../generated/gui_generated/src/numpad_screen/: numPadViewBase.cpp
  group Application/generated/gui_generated/perfilproductos_screen
    ../../generated/gui_generated/src/perfilproductos_screen/: PerfilProductosViewBase.cpp
  group Application/generated/gui_generated/screensaver_screen
    ../../generated/gui_generated/src/screensaver_screen/: ScreenSaverViewBase.cpp
  group Application/generated/gui_generated/teclado_screen
    ../../generated/gui_generated/src/teclado_screen/: tecladoViewBase.cpp
  group Application/generated/images
    ../../generated/images/src/: ayuda1.cpp ayuda2.cpp ayuda3.cpp ayuda4.cpp background-title.cpp background.cpp BitmapDatabase.cpp botonPerfil.cpp botonPerfilPressed.cpp bottom_slide_menu_background.cpp bottom_slide_menu_button.cpp box.cpp btn-central-push.cpp btn-central.cpp btn-ok-pressed.cpp btn-ok.cpp btn-pressed.cpp btn.cpp business.cpp cont1.cpp cont2.cpp cont3.cpp cont4.cpp container.cpp edit.cpp erase.cpp exit.cpp faq.cpp home.cpp icon_keyboard_even_row.cpp icon_keyboard_highlighted.cpp icon_keyboard_odd_row.cpp keyboard_background.cpp keyboard_key_delete_highlighted.cpp keyboard_key_highlighted.cpp keyboard_key_num_highlighted.cpp keyboard_key_shift_highlighted.cpp keyboard_space_highlighted.cpp left_slide_menu_background.cpp left_slide_menu_button.cpp menu_button_00.cpp menu_button_01.cpp menu_button_02.cpp menu_button_03.cpp menu_button_04.cpp menu_button_pressed_00.cpp menu_button_pressed_01.cpp menu_button_pressed_02.cpp menu_button_pressed_03.cpp menu_button_pressed_04.cpp menu_icon.cpp menu_toggle_button_00.cpp menu_toggle_button_01.cpp menu_toggle_button_02.cpp menu_toggle_button_03.cpp menu_toggle_button_selected_00.cpp menu_toggle_button_selected_01.cpp menu_toggle_button_selected_02.cpp menu_toggle_button_selected_03.cpp menuA.cpp menuB.cpp menuC.cpp menuD.cpp menuE.cpp menuF.cpp modal_background.cpp right_slide_menu_background.cpp right_slide_menu_button.cpp Round_icon_button.cpp Round_icon_button_pressed.cpp s.cpp ScreenSaver.cpp send.cpp sigfox.cpp sigfoxPressed.cpp text-field.cpp top_slide_menu_background.cpp top_slide_menu_button.cpp warning.cpp
  group Application/generated/images/__designer
    ../../generated/images/src/__designer/: blue_backgrounds_main_bg_480x272px.cpp Blue_Buttons_Round_Edge_icon_button.cpp Blue_Buttons_Round_Edge_icon_button_pressed.cpp Blue_Buttons_Round_Edge_small.cpp Blue_Buttons_Round_Edge_small_pressed.cpp Blue_Buttons_Round_icon_button.cpp Blue_Buttons_Round_icon_button_pressed.cpp Blue_Buttons_Round_small.cpp Blue_Buttons_Round_small_pressed.cpp Blue_Buttons_Square_icon_button.cpp Blue_Buttons_Square_icon_button_pressed.cpp Blue_Icons_Down_arrow_32.cpp Blue_Icons_Up_arrow_32.cpp Blue_PageIndicator_dot_indicator_small_highlight.cpp Blue_PageIndicator_dot_indicator_small_normal.cpp
  group Application/generated/texts
    ../../generated/texts/src/: LanguageGb.cpp Texts.cpp TypedTextDatabase.cpp
  group Application/gui/balanzainteligente_screen
    ../../gui/src/balanzainteligente_screen/: BalanzaInteligentePresenter.cpp BalanzaInteligenteView.cpp
  group Application/gui/common
    ../../gui/src/common/: CustomKeyboard.cpp FrontendApplication.cpp
  group Application/gui/informacion_screen
    ../../gui/src/informacion_screen/: InformacionPresenter.cpp InformacionView.cpp
  group Application/gui/menuprincipal_screen
    ../../gui/src/menuprincipal_screen/: MenuPrincipalPresenter.cpp MenuPrincipalView.cpp
  group Application/gui/model
    ../../gui/src/model/: Model.cpp
  group Application/gui/numpad_screen
    ../../gui/src/numpad_screen/: numPadPresenter.cpp numPadView.cpp
  group Application/gui/perfilproductos_screen
    ../../gui/src/perfilproductos_screen/: PerfilProductosPresenter.cpp PerfilProductosView.cpp
  group Application/gui/screensaver_screen
    ../../gui/src/screensaver_screen/: ScreenSaverPresenter.cpp ScreenSaverView.cpp
  group Application/gui/teclado_screen
    ../../gui/src/teclado_screen/: tecladoPresenter.cpp tecladoView.cpp
  group Application/main
    ../: main.cpp
  group Board/STM32F746G-DISCO
    ../bsp/source/: BoardConfiguration.cpp GPIO.cpp
  group Board/STM32F746G-DISCO/BSP
    ../bsp/source/bsp/: STM32F746GTouchController.cpp STM32F7Instrumentation.cpp
  group Board/STM32F746G-DISCO/Vendor
    ../bsp/source/vendor/Components/ft5336/: ft5336.c
    ../bsp/source/vendor/STM32746G-Discovery/: stm32746g_discovery.c stm32746g_discovery_lcd.c stm32746g_discovery_qspi.c stm32746g_discovery_sd.c stm32746g_discovery_sdram.c stm32746g_discovery_ts.c
  group MCU
    ../bsp/source/platform/stm32f7xx/: STM32F7DMA.cpp STM32F7HAL.cpp
  group MCU/stm32f7xx
    ../bsp/source/platform/stm32f7xx/IAR/: startup_stm32f746xx.s
    ../bsp/source/platform/stm32f7xx/STM32F7xx_HAL_Driver/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_can.c stm32f7xx_hal_cec.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_cryp.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_dac.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_eth.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_hash.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_hcd.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_i2s.c stm32f7xx_hal_irda.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_lptim.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_msp_template.c stm32f7xx_hal_nand.c stm32f7xx_hal_nor.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_spi.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_hal_wwdg.c stm32f7xx_ll_fmc.c stm32f7xx_ll_sdmmc.c stm32f7xx_ll_usb.c
    ../bsp/source/platform/stm32f7xx/CMSIS/: system_stm32f7xx.c
  group OS
    ../os/FreeRTOS8.2.0/: OSWrappers.cpp
  group OS/FreeRTOS8.2.0
    ../os/FreeRTOS8.2.0/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../os/FreeRTOS8.2.0/Source/portable/MemMang/: heap_2.c
    ../os/FreeRTOS8.2.0/Source/portable/IAR/ST_CM7/: port.c portasm.s
